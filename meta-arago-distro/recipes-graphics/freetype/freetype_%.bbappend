FREETYPE_ARAGO = ""
FREETYPE_ARAGO:arago = "freetype-arago.inc"

require ${FREETYPE_ARAGO}
