TSLIB_ARAGO = ""
TSLIB_ARAGO:arago = "tslib-arago.inc"

require ${TSLIB_ARAGO}
