WESTON_INIT_ARAGO = ""
WESTON_INIT_ARAGO:arago = "weston-init-arago.inc"

require ${WESTON_INIT_ARAGO}
