WESTON_ARAGO = ""
WESTON_ARAGO:arago = "weston-arago.inc"

require ${WESTON_ARAGO}
