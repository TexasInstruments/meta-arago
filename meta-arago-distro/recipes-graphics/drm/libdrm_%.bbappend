LIBDRM_ARAGO = ""
LIBDRM_ARAGO:arago = "libdrm-arago.inc"

require ${LIBDRM_ARAGO}
