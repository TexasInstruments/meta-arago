IPROUTE2_ARAGO = ""
IPROUTE2_ARAGO:arago = "iproute2-arago.inc"

require ${IPROUTE2_ARAGO}
