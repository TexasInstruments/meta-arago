LINUX_FIRMWARE_ARAGO = ""
LINUX_FIRMWARE_ARAGO:arago = "linux-firmware-arago.inc"

require ${LINUX_FIRMWARE_ARAGO}
