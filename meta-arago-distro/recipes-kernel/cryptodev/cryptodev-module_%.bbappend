CRYPTODEV_MODULE_ARAGO = ""
CRYPTODEV_MODULE_ARAGO:arago = "cryptodev-module-arago.inc"

require ${CRYPTODEV_MODULE_ARAGO}
