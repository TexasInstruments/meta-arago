LIBNL_ARAGO = ""
LIBNL_ARAGO:arago = "libnl-arago.inc"

require ${LIBNL_ARAGO}
