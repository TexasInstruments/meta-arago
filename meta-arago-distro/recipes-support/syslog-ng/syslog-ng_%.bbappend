SYSLOG_NG_ARAGO = ""
SYSLOG_NG_ARAGO:arago = "syslog-ng-arago.inc"

require ${SYSLOG_NG_ARAGO}
