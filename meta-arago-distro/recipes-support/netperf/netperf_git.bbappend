NETPERF_ARAGO = ""
NETPERF_ARAGO:arago = "netperf-arago.inc"

require ${NETPERF_ARAGO}
