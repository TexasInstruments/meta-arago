CIFS_UTILS_ARAGO = ""
CIFS_UTILS_ARAGO:arago = "cifs-utils-arago.inc"

require ${CIFS_UTILS_ARAGO}
