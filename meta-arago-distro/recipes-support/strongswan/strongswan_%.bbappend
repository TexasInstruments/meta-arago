STRONGSWAN_ARAGO = ""
STRONGSWAN_ARAGO:arago = "strongswan-arago.inc"

require ${STRONGSWAN_ARAGO}
