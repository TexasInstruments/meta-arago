PSPLASH_ARAGO = ""
PSPLASH_ARAGO:arago = "psplash-arago.inc"

require ${PSPLASH_ARAGO}
