SYSTEMD_ARAGO = ""
SYSTEMD_ARAGO:arago = "systemd-arago.inc"

require ${SYSTEMD_ARAGO}
