BUSYBOX_ARAGO = ""
BUSYBOX_ARAGO:arago = "busybox-arago.inc"

require ${BUSYBOX_ARAGO}
