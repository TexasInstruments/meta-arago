DBUS_ARAGO = ""
DBUS_ARAGO:arago = "dbus-arago.inc"

require ${DBUS_ARAGO}
