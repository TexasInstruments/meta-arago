INIT_IFUPDOWN_ARAGO = ""
INIT_IFUPDOWN_ARAGO:arago = "init-ifupdown-arago.inc"

require ${INIT_IFUPDOWN_ARAGO}
