EUDEV_ARAGO = ""
EUDEV_ARAGO:arago = "eudev-arago.inc"

require ${EUDEV_ARAGO}
