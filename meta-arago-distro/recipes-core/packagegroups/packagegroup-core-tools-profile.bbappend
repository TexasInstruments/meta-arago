PACKAGEGROUP_CORE_TOOLS_PROFILE_ARAGO = ""
PACKAGEGROUP_CORE_TOOLS_PROFILE_ARAGO:arago = "packagegroup-core-tools-profile-arago.inc"

require ${PACKAGEGROUP_CORE_TOOLS_PROFILE_ARAGO}
