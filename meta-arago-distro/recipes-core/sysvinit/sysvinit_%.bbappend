SYSVINIT_ARAGO = ""
SYSVINIT_ARAGO:arago = "sysvinit-arago.inc"

require ${SYSVINIT_ARAGO}
