BASE_FILES_ARAGO = ""
BASE_FILES_ARAGO:arago = "base-files-arago.inc"

require ${BASE_FILES_ARAGO}
