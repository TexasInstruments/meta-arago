ETHTOOL_ARAGO = ""
ETHTOOL_ARAGO:arago = "ethtool-arago.inc"

require ${ETHTOOL_ARAGO}
