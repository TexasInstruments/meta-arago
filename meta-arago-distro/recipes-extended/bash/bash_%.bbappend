BASH_ARAGO = ""
BASH_ARAGO:arago = "bash-arago.inc"

require ${BASH_ARAGO}
