SHADOW_SECURETTY_ARAGO = ""
SHADOW_SECURETTY_ARAGO:arago = "shadow-securetty-arago.inc"

require ${SHADOW_SECURETTY_ARAGO}
