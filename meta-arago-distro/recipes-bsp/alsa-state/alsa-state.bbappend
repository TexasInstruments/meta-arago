ALSA_STATE_ARAGO = ""
ALSA_STATE_ARAGO:arago = "alsa-state-arago.inc"

require ${ALSA_STATE_ARAGO}
