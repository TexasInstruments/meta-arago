CMAKE_ARAGO = ""
CMAKE_ARAGO:arago = "cmake-arago.inc"

require ${CMAKE_ARAGO}
