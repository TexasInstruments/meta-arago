PR:append = ".chromium0"

IMAGE_INSTALL:append = " chromium-ozone-wayland"
