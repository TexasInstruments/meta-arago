CHROMIUM_ARAGO = ""
CHROMIUM_ARAGO:arago = "chromium-ozone-wayland-arago.inc"

require ${CHROMIUM_ARAGO}
