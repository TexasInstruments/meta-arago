PR:append = ".selinux0"

IMAGE_INSTALL:append = " packagegroup-core-selinux"
