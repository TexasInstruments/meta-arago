TIFF_ARAGO = ""
TIFF_ARAGO:arago = "tiff-arago.inc"

require ${TIFF_ARAGO}
