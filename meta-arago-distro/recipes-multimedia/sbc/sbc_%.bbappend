SBC_ARAGO = ""
SBC_ARAGO:arago = "sbc-arago.inc"

require ${SBC_ARAGO}
