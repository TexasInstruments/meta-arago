PIPEWIRE_ARAGO = ""
PIPEWIRE_ARAGO:arago = "pipewire-arago.inc"

require ${PIPEWIRE_ARAGO}
