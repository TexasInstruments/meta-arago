WIREPLUMBER_ARAGO = ""
WIREPLUMBER_ARAGO:arago = "wireplumber-arago.inc"

require ${WIREPLUMBER_ARAGO}
