GSTREAMER1p0_PLUGINS_GOOD_1p22_ARAGO = ""
GSTREAMER1p0_PLUGINS_GOOD_1p22_ARAGO:arago = "gstreamer1.0-plugins-good_1.22-arago.inc"

require ${GSTREAMER1p0_PLUGINS_GOOD_1p22_ARAGO}
