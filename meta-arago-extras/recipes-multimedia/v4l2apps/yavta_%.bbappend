YAVTA_ARAGO = ""
YAVTA_ARAGO:arago = "yavta-arago.inc"

require ${YAVTA_ARAGO}
