V4L_UTILS_ARAGO = ""
V4L_UTILS_ARAGO:arago = "v4l-utils-arago.inc"

require ${V4L_UTILS_ARAGO}
