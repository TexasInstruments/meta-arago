DUMMYPROVIDES += "\
    nativesdk-perl-dev \
    nativesdk-perl-module-feature \
    nativesdk-perl-module-file-spec-unix \
    nativesdk-perl-module-integer \
    nativesdk-perl-module-symbol \
"
