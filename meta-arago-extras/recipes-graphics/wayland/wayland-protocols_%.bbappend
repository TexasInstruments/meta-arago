WAYLAND_PROTOCOLS_ARAGO = ""
WAYLAND_PROTOCOLS_ARAGO:arago = "wayland-protocols-arago.inc"

require ${WAYLAND_PROTOCOLS_ARAGO}
