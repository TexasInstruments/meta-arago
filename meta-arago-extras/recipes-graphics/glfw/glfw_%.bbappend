GLFW_ARAGO = ""
GLFW_ARAGO:arago = "glfw-arago.inc"

require ${GLFW_ARAGO}
