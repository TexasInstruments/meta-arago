MESON_ARAGO = ""
MESON_ARAGO:arago = "meson-arago.inc"

require ${MESON_ARAGO}
