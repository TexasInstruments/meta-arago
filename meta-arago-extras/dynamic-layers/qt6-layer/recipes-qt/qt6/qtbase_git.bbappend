QTBASE_ARAGO = ""
QTBASE_ARAGO:arago = "qtbase-arago.inc"

require ${QTBASE_ARAGO}
