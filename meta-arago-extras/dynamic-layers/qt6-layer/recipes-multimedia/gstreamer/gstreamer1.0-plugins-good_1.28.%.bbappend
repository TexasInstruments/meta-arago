GSTREAMER1p0_PLUGINS_GOOD_1p28_ARAGO = ""
GSTREAMER1p0_PLUGINS_GOOD_1p28_ARAGO:arago = "gstreamer1.0-plugins-good_1.28-arago.inc"

require ${GSTREAMER1p0_PLUGINS_GOOD_1p28_ARAGO}
