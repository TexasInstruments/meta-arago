OPEN62541_ARAGO = ""
OPEN62541_ARAGO:arago = "open62541-arago.inc"

require ${OPEN62541_ARAGO}
