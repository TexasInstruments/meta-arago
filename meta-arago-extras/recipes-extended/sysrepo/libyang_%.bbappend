LIBYANG_ARAGO = ""
LIBYANG_ARAGO:arago = "libyang-arago.inc"

require ${LIBYANG_ARAGO}

BBCLASSEXTEND = "native nativesdk"
