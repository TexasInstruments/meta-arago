ABSEIL_CPP_ARAGO = ""
ABSEIL_CPP_ARAGO:arago = "abseil-cpp-arago.inc"

require ${ABSEIL_CPP_ARAGO}
