BPFTOOL_TI = ""
BPFTOOL_TI:ti-soc = "bpftool-ti.inc"

require ${BPFTOOL_TI}
