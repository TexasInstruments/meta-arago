
PM_QA_ARAGO = ""
PM_QA_ARAGO:arago = "pm-qa-arago.inc"

require ${PM_QA_ARAGO}

