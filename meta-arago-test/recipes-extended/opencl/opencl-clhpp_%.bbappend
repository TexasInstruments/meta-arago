OPENCL_HEADERS_TI = ""
OPENCL_HEADERS_TI:ti-soc = "opencl_clhpp-ti.inc"

require ${OPENCL_HEADERS_TI}
