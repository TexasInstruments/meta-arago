OPENCL_HEADERS_TI = ""
OPENCL_HEADERS_TI:ti-soc = "opencl_headers-ti.inc"

require ${OPENCL_HEADERS_TI}
