# Include the examples for Qt6 related tests

PACKAGECONFIG:append = " examples"
